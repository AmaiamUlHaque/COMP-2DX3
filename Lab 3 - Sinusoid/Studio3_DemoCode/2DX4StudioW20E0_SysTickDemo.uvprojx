# Keil uVision project 2DX4StudioW20E0_SysTickDemo.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2DX4StudioW20E0_SysTickDemo
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: 2DX4StudioW2E0_SysTickDemo.c PLL.c SysTick.c
software components: CMSIS:CORE 6.1.0, Device:Startup 3.2.3
